## boards/shields/corne_choc_pro/Kconfig.shield
```kconfig
config SHIELD_CORNE_CHOC_PRO_DONGLE
    def_bool $(shields_list_contains,corne_choc_pro_dongle)
```
